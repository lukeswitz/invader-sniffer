## sdkconfig.defaults
```kconfig
CONFIG_BT_ENABLED=y
CONFIG_BT_BLE_ENABLED=y
CONFIG_BLUEDROID_ENABLED=y
CONFIG_BT_CTRL_MODE_EFF=1
CONFIG_BTDM_CTRL_MODE_BLE_ONLY=y
```
